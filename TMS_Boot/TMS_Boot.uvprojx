# Keil uVision project TMS_Boot.uvprojx, settings and files
target TMS_Boot (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TMS_Boot +hex
  AfterMake: d:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o TMS_Boot.bin  ./Objects/TMS_Boot.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,__BOOT__,Z_DEVICE=CCULED,DEBUG_ERR_CONSOLE_ON1,DEBUG_WAR_CONSOLE_ON1
  c include: .\code\STM32F4xx_DSP_StdPeriph_Lib_V1.7.1\STM32F4xx_StdPeriph_Driver\inc;.\code\STM32F4xx_DSP_StdPeriph_Lib_V1.7.1\CMSIS\Include;.\code\STM32F4xx_DSP_StdPeriph_Lib_V1.7.1\CMSIS\Device\ST\STM32F4xx\Include;.\code\Source;.\code\STM32Config;.\code\UserLib;.\code\CanFestival-3-8bfe0ac00cdb\include;.\code\CanFestival-3-8bfe0ac00cdb\drivers\stm32;.\code\CanFestival-3-8bfe0ac00cdb\src;.\code\CanFestival-3-8bfe0ac00cdb\include\stm32;.\code\CanFestival-3-8bfe0ac00cdb\examples\stm32\common;.\code\CanFestival-3-8bfe0ac00cdb\ObjDict;.\code\IAP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xc000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source
    ./code/Source/: main.c
  group STM32Config
    ./code/STM32Config/: sysconfig.c stm32f4xx_it.c
  group STM32F4xx_StdPeriph_Driver
    ./code/STM32F4xx_DSP_StdPeriph_Lib_V1.7.1/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_spdifrx.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_spi.c
  group CMSIS
    ./code/STM32F4xx_DSP_StdPeriph_Lib_V1.7.1/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ./code/STM32F4xx_DSP_StdPeriph_Lib_V1.7.1/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group UserLib
    ./code/UserLib/: uart1.c user_stdio.c led.c debug_tools.c can_address.c applib.c flash_if.c wdg.c
  group CANFestival_src
    ./code/CanFestival-3-8bfe0ac00cdb/src/: dcf.c emcy.c lifegrd.c lss.c nmtMaster.c nmtSlave.c objacces.c pdo.c sdo.c states.c sync.c timer.c
  group CANFestival_drv
    ./code/CanFestival-3-8bfe0ac00cdb/drivers/stm32/: can_STM32.c timer_STM32.c MTD_CCU_CAN3_MCP2515.c MTD_CCU_SPI.c
  group ObjDict
    ./code/CanFestival-3-8bfe0ac00cdb/ObjDict/: TMS_Boot_ObjDict_m.c TMS_Boot_ObjDict_s.c
  group IAP
    ./code/IAP/: iap.c IAP_Processor.c IAP_UART.c tools.c
